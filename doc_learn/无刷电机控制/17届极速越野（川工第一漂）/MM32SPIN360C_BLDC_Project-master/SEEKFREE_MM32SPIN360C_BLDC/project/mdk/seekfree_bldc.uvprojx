# Keil uVision project seekfree_bldc.uvprojx, settings and files
target seekfree_bldc (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MM32SPIN27PF MindMotion
  pack: MindMotion.MM32SPIN2x_DFP.1.1.4
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: seekfree_bldc +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\sdk\CMSIS\KEIL_CORE;..\..\Libraries\sdk\MM32SPIN2xx_p_LIB\Source\KEIL_StartAsm;..\..\Libraries\sdk\MM32SPIN2xx_p_LIB\Include;..\..\Libraries\sdk\MM32SPIN2xx_p_LIB\HAL_lib\inc;..\..\Libraries\hardware;..\..\Libraries\bldc;..\USER
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group user
    ../USER/: main.c isr.c isr.h
  group hardware
    ../../Libraries/hardware/: adc.c adc.h common.c common.h comp.c comp.h gpio.c gpio.h opamp.c opamp.h pwm_input.c pwm_input.h timer.c timer.h uart.c uart.h
  group bldc
    ../../Libraries/bldc/: motor.c motor.h pid.c pid.h hall.c hall.h move_filter.c move_filter.h virsco.c virsco.h bldc_config.h version.txt
  group hal_library
    ../../Libraries/sdk/MM32SPIN2xx_p_LIB/HAL_lib/src/: HAL_adc.c HAL_comp.c HAL_crc.c HAL_div.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_op.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
  group startup
    ../../Libraries/sdk/MM32SPIN2xx_p_LIB/Source/: system_MM32SPIN2xx_p.c
    ../../Libraries/sdk/MM32SPIN2xx_p_LIB/Source/KEIL_StartAsm/: startup_MM32SPIN2xx_p.s
